# Keil uVision project Test_Proj_Virt1.uvprojx, settings and files
target Virt1 (6180000::V6.18::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Virt1 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ./bincopy.exe -i $L@L.bin -o $L@L.c
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ../Source;../Include;../Guest/M5P1_MuProkaron/MProkaron/Include;.
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x8000000 size 0x10000
  scatter file: ../Source/proc_virt1.sct
  group Virt1
    ../Source/: rvm_guest.c rvm_guest_a7m.c rvm_guest_a7m_asm.s rvm_proc_asm.s proc_virt1.c
    ../Guest/M5P1_MuProkaron/MProkaron/Kernel/: rmp_kernel.c
    ../Guest/M5P1_MuProkaron/MProkaron/Platform/A7M_RVM/: rmp_platform_a7m_rvm.c rmp_platform_a7m_rvm_asm.s
    ../Guest/M5P1_MuProkaron/MProkaron/User/: rmp_blank.c

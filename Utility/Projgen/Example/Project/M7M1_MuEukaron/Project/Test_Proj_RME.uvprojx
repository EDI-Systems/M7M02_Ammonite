# Keil uVision project Test_Proj_RME.uvprojx, settings and files
target RME (6180000::V6.18::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RME +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ./Source;./Include;../MEukaron/Include;.
  asm include: ./Source;./Include;../MEukaron/Include;.
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x8000000 size 0x10000
  scatter file: ../MEukaron/Include/Platform/A7M/Chips/STM32F405RG/rme_platform_STM32F405RG.sct
  link misc: --keep=*RVM.o --keep=*Proc1.o --keep=*Proc2.o --keep=*Virt1.o
  group RME
    ./Source/: rme_boot.c rme_user.c
    ../MEukaron/Kernel/: rme_kernel.c
    ../MEukaron/Platform/A7M/: rme_platform_a7m.c rme_platform_a7m_asm.s
    ../../M7M2_MuAmmonite/Project/Objects/: RVM.c
    ../../Proc_Proc1/Project/Objects/: Proc1.c
    ../../Proc_Proc2/Project/Objects/: Proc2.c
    ../../Proc_Virt1/Project/Objects/: Virt1.c

# Keil uVision project M7M2_Init.uvprojx, settings and files
target Init (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M7M2_Init +hex
  BeforeMake: copy.bat
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: bincopy.exe -i $L@L.bin -o $L@L.c
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Init\Include;..\..\..\Lib\Include;..\..\..\..\M7M1_MuEukaron\MEukaron\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\Init\Include\Platform\CortexM\Chips\STM32F405RG\init_STM32F405RG.sct
  link misc: --keep=syslib_cmx_asm.o
  group Init
    ../../../Init/: init.c
    ../../../Init/Include/Platform/CortexM/Chips/STM32F405RG/: init_STM32F405RG.sct
  group Lib
    ../../../Lib/Syslib/: syssvc.c
    ../../../Lib/Platform/CortexM/: syslib_cmx_asm.s syslib_cmx.c
    ./: redirect.c

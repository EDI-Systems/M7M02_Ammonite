# Keil uVision project M7M2_Init.uvprojx, settings and files
target Init (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: M7M2_Init +hex
  BeforeMake: copy.bat
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: bincopy.exe -i $L@L.bin -o $L@L.c
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\MAmmonite\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\MAmmonite\Include\Platform\A7M\Chips\STM32F767IG\rvm_platform_STM32F767IG.sct
  link misc: --keep=rvm_platform_a7m_asm.o
  group Init
    ../../MAmmonite/Init/: rvm_init.c rvm_syssvc.c rvm_hyper.c
  group Platform
    ./: redirect.c
    ../../MAmmonite/Platform/A7M/: rvm_platform_a7m.c rvm_platform_a7m_asm.s
    ../../MAmmonite/Include/Platform/A7M/Chips/STM32F767IG/: rvm_platform_STM32F767IG.sct
